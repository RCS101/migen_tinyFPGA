# Repository RCS101/migen_tinyFPGA

## KiCad design TinyFPGA-A-Series/board/TinyFPGA-A.kicad_pcb

Board: 2 copper layers, 17.8 x 30.5 mm, 17 parts (0 on the bottom side), 25 nets.

Parts:
C1: 10uF; C_0603
C2: 1uF; C_0603
C3, C4, C6, C8, C9: 100nF; C_0603
C5, C7, C10, C11: 10nF; C_0603
J1, J2: CONN_01X12; Pin_Header_Straight_1x12_Pitch2.54mm
J3: CONN_01X05; Pin_Header_Straight_1x05_Pitch2.54mm
L1: bead; L_0603
R1: 4.7k; R_0603
U1: LCMXO2-1200HC-4SG32C; 32QFN

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, L1.1, U1.2, U1.6, U1.7, U1.15, U1.18, U1.19, U1.24, U1.31
EXT3v3: C1.1, C2.1, C3.1, J2.1, L1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.1, J3.4, R1.2, U1.3, U1.22, U1.33
PB4C/CS: J2.6, U1.8
PB6C/SCLK: J2.5, U1.9
PB6D/MISO: J2.4, U1.10
PB9A: J2.3, U1.11
PB9B: J2.2, U1.12
PB11A: J1.2, U1.13
PB11B: J1.3, U1.14
PB20C/SN: J1.4, U1.16
PB20D/MOSI: J1.5, U1.17
PL9A: J2.8, U1.4
PL9B: J2.7, U1.5
PR5C: J1.7, U1.21
PR5D: J1.6, U1.20
PT12C/SCL: J1.12, U1.28
PT12D/SDA: J1.11, U1.27
PT15C/JTAGENB: J1.10, U1.26
PT15D/PROGRAMN: J1.9, U1.25
PT17D/DONE: J1.8, U1.23
TCK: J2.10, J3.2, R1.1, U1.30
TDI: J2.11, J3.3, U1.32
TDO: J2.12, J3.5, U1.1
TMS: J2.9, J3.1, U1.29

## Commit log

2020-03-24 Tidy
2020-03-24 Added tinyPlatform
2020-03-24 verilog test
2020-03-25 Home version
2020-03-25 Working blinky demo. Still get error -pnmainc is not recognised- but the .v and .lpf can be copied into template_a2.v & .lpf and lattice generates the correct bitstream
2020-03-30 SPI slave dirty sim kinda working
2020-03-30 Fixed data wiping issue
2020-03-31 Fixed SPI. Now working in LSB mode
2020-04-02 SPI to WS2812b kind of working. Writes to ws2812 correctly but misses a lot of SPI commands, probably caused by error during SPI write
2020-04-27 some changes
2020-05-19 Memory test
2020-05-19 Basic reading from memory
2020-05-19 Reading mem ovre ports
2020-05-20 test
2020-05-20 delted comment
2020-05-20 Failing to build verilog
2020-05-20 Corrected - added port to specials
